# Keil uVision project program.uvproj, settings and files
target MCB2300 (ARM-ADS)
  device: LPC2378 NXP (founded by Philips)
  cpu: IRAM(0x40000000-0x40007FFF) IRAM2(0x7FE00000-0x7FE03FFF) IROM(0-0x7FFFF) CLOCK(12000000) CPUTYPE(ARM7TDMI)
  output: program
  c flags: Optim=1
  c include: .\general\inc;.\inc
  asm include: .\general\inc
  library: MicroLIB
  memory RVCT4: ROM 0x0 size 0x80000
  memory RVCT9: RAM 0x40000000 size 0x8000
  memory RVCT10: RAM 0x7fe00000 size 0x4000
  group general_src
    ./general/src/: LCD_4bit.c LED.c timing.c LPC2300.s IRQ.c button.c
  group general_inc
    ./general/inc/: LCD.h LED.h timing.h IRQ.h button.h
  group src
    ./src/: program.c
  group inc
    ./inc/: program.h
